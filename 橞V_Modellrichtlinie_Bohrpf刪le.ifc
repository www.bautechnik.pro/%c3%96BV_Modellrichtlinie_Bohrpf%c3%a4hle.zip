Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: ÖBV_OEBV_Richtlinie_Bohrpfähle.ifc
Time: 2024-03-13T09:32:16
Author: Oesterreichische Bautechnik Vereinigung
Organization: OEBV
Written by: ODA SDAI 24.5
Authorization: OEBV

# IfcSite, Liegenschaft
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingStorey, Geschoss 01
In: Gebäude
Elevation: 0 m

# IfcPile (5)
In: Geschoss 01
Description: Innenwand; Material: C25/30
Name | Allright_Bauteil_ID
 | 0035St 0000000007
 | 0035St 0000001643
 | 0035St 0000000013
 | 0035St 0000000011
 | 0035St 0000000015
